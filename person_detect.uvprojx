# Keil uVision project person_detect.uvprojx, settings and files
target libtf_person_detect_model_data (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: libtf_person_detect_model_data (library)
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CM7
  c include: C:/Users/nxf48054/Desktop/share/tensorflow
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/person_model_grayscale/: person_detect_model_data.cc person_detect_model_data.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
