# Keil uVision project libtf.uvprojx, settings and files
target libtf (6100001::V6.10.1::.\ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.12.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: libtf (library)
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TF_LITE_STATIC_MEMORY,TF_LITE_DISABLE_X86_NEON,TF_LITE_MCU_DEBUG_LOG,CPU_M7=1,CMSIS_NN
  c include: C:/Users/nxf48054/Desktop/share/tensorflow/.;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/gemmlowp;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/flatbuffers/include;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/ruy;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/Core/Include;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/DSP/Include;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Include;C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/kissfft
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: libtf.cc libtf.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/c/: common.c common.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h tensor_utils.cc tensor_utils.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/kernels/internal/: quantization_util.cc quantization_util.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/kernels/: kernel_util.cc kernel_util.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h recording_micro_allocator.cc recording_micro_allocator.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.cc keyword_scrambled_model_data.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/cortex_m_generic/: debug_log.cc
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/kernels/: activations.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc dequantize.cc detection_postprocess.cc elementwise.cc ethosu.cc ethosu.h flexbuffers_generated_data.cc flexbuffers_generated_data.h floor.cc fully_connected_common.cc hard_swish.cc kernel_runner.cc kernel_runner.h kernel_util.cc kernel_util.h l2norm.cc logical.cc logistic.cc maximum_minimum.cc neg.cc pack.cc pad.cc prelu.cc quantize.cc quantize.h quantize_common.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc shape.cc softmax_common.cc split.cc split_v.cc strided_slice.cc sub.cc svdf_common.cc tanh.cc transpose_conv.cc unpack.cc
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/kernels/cmsis_nn/: add.cc conv.cc depthwise_conv.cc fully_connected.cc mul.cc pooling.cc softmax.cc svdf.cc
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/openmvcam/: debug_log.cc
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/testing/: test_conv_model.cc test_conv_model.h
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_mul_s8.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConcatenationFunctions/: arm_concatenation_s8_w.c arm_concatenation_s8_x.c arm_concatenation_s8_y.c arm_concatenation_s8_z.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_s8.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_u8_basic_ver1.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s8.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/PoolingFunctions/: arm_avgpool_s8.c arm_max_pool_s8.c arm_pool_q7_HWC.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/ReshapeFunctions/: arm_reshape_s8.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/SVDFunctions/: arm_svdf_s8.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/micro/tools/make/downloads/cmsis/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s8.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    C:/Users/nxf48054/Desktop/share/tensorflow/tensorflow/lite/schema/: schema_utils.cc schema_utils.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
